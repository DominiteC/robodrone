# Keil uVision project project.uvprojx, settings and files
target project (6220000::V6.22::ARMCLANG)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../user/domain;../user/app;../user/tool;../user/tool/log;../user/tool/log/lwrb;../user/tool/log/printf;../user/tool/USMART;../user/sys;../user/hardware/usart;../user/module;../user/module/mtf01;../user/module/bn220;../user/module/motor;../user/module/gyro;../user/module/bmp280;../user/module/RF;../user/module/at24c02;../user/abstract;../user/control;../user/services;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/ST/ARM/DSP/Inc
  asm include: ../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group tool
    ../user/tool/log/: log.c log_port.c usart_send.c usart_send_port.c
    ../user/tool/log/lwrb/: lwrb.c lwrb_ex.c
    ../user/tool/log/printf/: printf.c
    ../user/tool/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group sys
    ../user/sys/: globalTime.c IT_Callback.c Mydelay.c watchdog_guard.c
  group hardware
    ../user/hardware/usart/: usart_port.c
  group module
    ../user/module/mtf01/: mtf_01.c
    ../user/module/bn220/: bn220.c minmea.c
    ../user/module/motor/: esc.c motor.c servo.c actuator.c
    ../user/module/gyro/: jy901p.c arm_transform.c
    ../user/module/bmp280/: bmp280.c
    ../user/module/RF/: nRF24L01P.c
    ../user/module/at24c02/: AT24Cxx.c
  group abstract
    ../user/abstract/: gyro.c position.c ANO_DT.c
  group domain
    ../user/domain/: vector_types.h flight_mode.h vehicle_state.h actuator_types.h drone_params.h drone_types.h
  group app
    ../user/app/: app_init.c app_init.h app_diagnostics.c app_diagnostics.h app_system.c app_system.h app_tasks.c app_tasks.h app_config.h
  group control
    ../user/control/: control.c PIDcontroller.c change.c
  group services
    ../user/services/: remotedata.c commander.c remotedata.h commander.h wireless.c wireless.h alarm.c alarm.h
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
software components: CMSIS:CORE 5.6.0
